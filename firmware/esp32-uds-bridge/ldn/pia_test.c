#include "pia_crypto.h"
#include <stdio.h>
#include <stdlib.h>
#define ZSTD_STATIC_LINKING_ONLY
#include "zstd.h"
#include "esp_heap_caps.h"
#include "esp_system.h"

/* Datagram captured from a real Switch session, with the plaintext from an independent
   implementation. Checks key derivation, nonce, tag placement and zstd body. */
static const uint8_t kSsid[16] = {
    0x4f, 0x3b, 0x51, 0x39, 0x85, 0xd8, 0x3e, 0xda, 0x42, 0x14, 0xc2, 0xa1,
    0xe6, 0xd4, 0xea, 0x54,
};
static const char kSourceIp[] = "169.254.47.1";
static const uint8_t kDatagram[] = {
    0x32, 0xab, 0x98, 0x64, 0x90, 0x83, 0x00, 0x00, 0x59, 0x6e, 0x00, 0x00,
    0x00, 0xea, 0x57, 0xd4, 0x38, 0x70, 0xe9, 0xdc, 0xd8, 0xb1, 0xe7, 0x15,
    0x26, 0x82, 0x22, 0x03, 0x86, 0x8a, 0x4a, 0xfa, 0xde, 0x94, 0x96, 0x3c,
    0x60, 0xc0, 0x49, 0xb7, 0x22, 0x61, 0x40, 0x1b, 0x30, 0x24, 0xa3, 0x38,
    0x72, 0x5d, 0x01, 0x8f, 0xff, 0xf7, 0xa2, 0x57, 0x6a, 0x45, 0x6a, 0x40,
    0xa3, 0x47, 0xbb, 0x9a, 0x28, 0x63, 0xb6, 0xde, 0x09, 0xd0, 0x5a, 0x95,
    0xba, 0x68, 0x42, 0x25, 0x58, 0xcc, 0xd9, 0xfc, 0x24, 0x77, 0xf8, 0xbb,
    0x1e, 0x2f, 0xab, 0x05, 0xb7, 0xd8, 0xbf, 0x9b, 0x8e, 0xe7, 0xf0, 0xae,
    0x80, 0x77, 0x1d, 0x29, 0xc7, 0x22, 0x17, 0x58, 0x5f, 0xef, 0x2a, 0xb8,
    0x97,
};
static const uint8_t kPlain[] = {
    0x28, 0xb5, 0x2f, 0xfd, 0x00, 0x18, 0xfd, 0x01, 0x00, 0xa4, 0x02, 0x06,
    0x00, 0xa2, 0x01, 0x01, 0x11, 0x00, 0x84, 0x00, 0x00, 0x00, 0x02, 0x59,
    0x6e, 0xca, 0x0c, 0x06, 0xea, 0xf9, 0x74, 0x00, 0x1d, 0xce, 0xd8, 0x91,
    0x01, 0x00, 0x06, 0x00, 0xa9, 0xfe, 0x2f, 0x01, 0x00, 0x30, 0x39, 0x00,
    0x01, 0x02, 0xff, 0x00, 0x00, 0x08, 0x00, 0x07, 0x12, 0xc1, 0x10, 0x33,
    0xb9, 0x03, 0xcd, 0x72, 0xb6, 0x0c, 0x42, 0x03, 0xc6, 0x0b, 0x80, 0x09,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff,
};

/* Same session: largest datagram seen, a resend of 74 unacked reliable frames.
   381 bytes on the wire, 7182 decompressed. */
static const uint8_t kBatch[] = {
    0x32, 0xab, 0x98, 0x64, 0x90, 0x91, 0xc4, 0x93, 0x59, 0x6e, 0xd7, 0xcd,
    0x02, 0xea, 0x57, 0xd4, 0x38, 0x70, 0xea, 0xd9, 0xb9, 0x4e, 0x01, 0xbc,
    0x3f, 0x44, 0x6a, 0xd1, 0xbe, 0xe4, 0x63, 0x9e, 0xce, 0x5c, 0x75, 0xfd,
    0x8f, 0xe1, 0x31, 0x75, 0xda, 0xe2, 0x91, 0x9e, 0x0e, 0x6f, 0xc1, 0xdd,
    0x27, 0x43, 0x64, 0x6a, 0x57, 0xcd, 0x4e, 0x14, 0x05, 0xcc, 0x49, 0x48,
    0xbd, 0xb0, 0xfe, 0x28, 0xd1, 0xa9, 0x43, 0x3c, 0x6e, 0xc5, 0xdf, 0x75,
    0x11, 0xfb, 0xec, 0x3e, 0x8a, 0xcc, 0xa2, 0xc8, 0x1a, 0xd1, 0xd9, 0xde,
    0x92, 0x4e, 0x8d, 0x8c, 0xa2, 0x1d, 0x82, 0xaa, 0x9a, 0xb5, 0x93, 0x56,
    0x0e, 0x49, 0x80, 0x55, 0x88, 0x0d, 0x94, 0xf1, 0xcb, 0xdf, 0x3b, 0x62,
    0xad, 0x8f, 0x95, 0xc7, 0xb9, 0x39, 0x62, 0xba, 0x0d, 0xb0, 0xd2, 0x9c,
    0x3f, 0xf2, 0x59, 0x01, 0x49, 0x36, 0xaa, 0x0c, 0x15, 0xb5, 0x0a, 0x9d,
    0x16, 0x3a, 0x6c, 0x53, 0x7a, 0xe5, 0xbc, 0xcf, 0xcf, 0x0d, 0x4e, 0x83,
    0x41, 0x86, 0x40, 0x39, 0x68, 0xdd, 0xa2, 0xdf, 0xcf, 0x7d, 0x1c, 0x39,
    0x87, 0x72, 0x4b, 0x61, 0x57, 0x24, 0x82, 0x18, 0x28, 0x14, 0xeb, 0x40,
    0xae, 0x0d, 0x8e, 0x15, 0xd3, 0xc0, 0x34, 0xc7, 0x8c, 0x21, 0x17, 0x2e,
    0x95, 0xee, 0x86, 0x76, 0xf5, 0xad, 0x7f, 0xdc, 0xa0, 0x5d, 0x23, 0x4d,
    0x05, 0xd1, 0xfd, 0x76, 0xf5, 0xbc, 0x63, 0x81, 0x9e, 0x0a, 0x7d, 0xef,
    0x0c, 0x26, 0x15, 0x02, 0x3e, 0x76, 0x8b, 0xae, 0x6e, 0xfd, 0x37, 0x3b,
    0x13, 0x85, 0x01, 0x83, 0x72, 0x57, 0x27, 0xc5, 0xbd, 0x08, 0x86, 0x57,
    0xe7, 0xae, 0xa4, 0x1a, 0x14, 0x0a, 0x4d, 0x99, 0x8a, 0xe1, 0x6e, 0x7d,
    0xed, 0x58, 0x12, 0x3f, 0x90, 0x0e, 0xf3, 0xab, 0xa1, 0xea, 0xfb, 0xe5,
    0x9e, 0x38, 0x31, 0xfd, 0xf7, 0x0f, 0x59, 0x9f, 0x20, 0x48, 0x0e, 0xbe,
    0x53, 0x6f, 0x71, 0x12, 0x3a, 0xe7, 0x62, 0x0a, 0x6d, 0x49, 0xa9, 0x4b,
    0xf4, 0xd2, 0x9e, 0xa2, 0x8e, 0x82, 0x9f, 0xac, 0xa0, 0xf3, 0x5f, 0x49,
    0x96, 0x9b, 0x78, 0xa5, 0x24, 0x03, 0xe5, 0x86, 0x7e, 0x59, 0xdb, 0xb5,
    0x13, 0x05, 0x93, 0x04, 0x1d, 0x5e, 0x1e, 0x31, 0x89, 0xcc, 0x00, 0x42,
    0x94, 0x80, 0xfb, 0x50, 0xda, 0xbd, 0x33, 0xbd, 0x16, 0x23, 0xae, 0x41,
    0x22, 0xb3, 0xbf, 0xbc, 0x07, 0x98, 0x88, 0x2b, 0x63, 0xcd, 0xad, 0x78,
    0xa5, 0xd4, 0x50, 0xd2, 0xd8, 0x9e, 0x5f, 0xd8, 0x13, 0xbb, 0x73, 0xd6,
    0x32, 0x84, 0x39, 0x70, 0x81, 0x80, 0x7c, 0xdb, 0x18, 0xcf, 0x66, 0xa0,
    0xea, 0xb8, 0xc7, 0xa8, 0x91, 0xd7, 0x3b, 0x0c, 0x88, 0x8a, 0x07, 0x6e,
    0x50, 0x07, 0x49, 0x14, 0xa5, 0x65, 0x3d, 0xcc, 0x30,
};
#define BATCH_BODY 7182
#define BATCH_MESSAGES 74

/* Decrypt and decompress kBatch. Returns its message count, or a negative stage number. */
static int selftest_batch(const pia_crypto_t *c, uint8_t *plain, int *body_size)
{
    int n = pia_decrypt(c, kBatch, sizeof(kBatch), kSourceIp, plain, PIA_MAX_BODY);
    if (n < 0) return -1;
    int trimmed = n - (kBatch[5] >> 4) - kBatch[12];
    if (trimmed < 0) return -2;
    /* Switch frames carry no content size. */
    uint8_t *body = malloc(8192);
    if (!body) return -4;
    *body_size = pia_decompress(plain, (size_t)trimmed, body, 8192);
    int count = 0;
    if (*body_size > 0)
    {
        pia_message_iter_t it;
        pia_message_t m;
        pia_message_iter_init(&it, body, (size_t)*body_size);
        while (pia_message_next(&it, &m)) ++count;
    }
    free(body);
    return *body_size > 0 ? count : -5;
}

int pia_selftest(char *out, size_t cap)
{
    pia_crypto_t c;
    pia_crypto_init(&c, kSsid);

    /* Heap, not static: runs only on request; the bridge needs the RAM. */
    uint8_t *plain = malloc(PIA_MAX_BODY), *body = malloc(PIA_MAX_BODY);
    if (!plain || !body) { free(plain); free(body); return snprintf(out, cap, "nomem"); }
    int written = 0;
    int n = pia_decrypt(&c, kDatagram, sizeof(kDatagram), kSourceIp, plain, PIA_MAX_BODY);
    if (n < 0) { written = snprintf(out, cap, "decrypt=FAIL"); goto done; }
    const size_t need = ZSTD_estimateDCtxSize();
    const size_t heap = esp_get_free_heap_size();
    const size_t largest = heap_caps_get_largest_free_block(MALLOC_CAP_8BIT);
    if (n != (int)sizeof(kPlain) || memcmp(plain, kPlain, (size_t)n) != 0)
    {
        written = snprintf(out, cap, "decrypt=MISMATCH len=%d expected=%u", n, (unsigned)sizeof(kPlain));
        goto done;
    }

    /* Header byte 5 bit 0: compressed body. */
    int padding = kDatagram[5] >> 4, footer = kDatagram[12];
    int trimmed = n - padding - footer;
    if (trimmed < 0) { written = snprintf(out, cap, "decrypt=OK footer=BAD"); goto done; }
    int m = (kDatagram[5] & 1) ? pia_decompress(plain, (size_t)trimmed, body, PIA_MAX_BODY) : trimmed;
    if (m < 0)
    {
        written = snprintf(out, cap, "decrypt=OK unzip=FAIL dctx_needs=%u heap=%u largest=%u",
                           (unsigned)need, (unsigned)heap, (unsigned)largest);
        goto done;
    }
    if (!(kDatagram[5] & 1)) memcpy(body, plain, (size_t)trimmed);

    pia_message_t messages[PIA_MAX_MESSAGES];
    int count = pia_messages_decode(body, (size_t)m, messages, PIA_MAX_MESSAGES);

    /* Raw-block frame round trip through pia_decompress. */
    uint8_t round[64], back[64];
    int r = pia_compress_raw(kPlain, 32, round, sizeof(round));
    int rb = r > 0 ? pia_decompress(round, (size_t)r, back, sizeof(back)) : -1;
    bool raw_ok = rb == 32 && memcmp(back, kPlain, 32) == 0;

    int batch_body = 0;
    int batch = selftest_batch(&c, plain, &batch_body);
    bool batch_ok = batch == BATCH_MESSAGES && batch_body == BATCH_BODY;

    written = snprintf(out, cap, "decrypt=OK plain=%d unzip=%d messages=%d proto0=%u rawframe=%s "
                       "batch=%s(%d/%d) dctx_needs=%u heap=%u largest=%u",
                       n, m, count, count > 0 ? messages[0].protocol : 0, raw_ok ? "OK" : "FAIL",
                       batch_ok ? "OK" : "FAIL", batch_body, batch,
                       (unsigned)need, (unsigned)heap, (unsigned)largest);
done:
    free(plain);
    free(body);
    return written;
}
